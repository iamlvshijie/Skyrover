# Keil uVision project PSS.uvproj, settings and files
target PSS (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: PSS +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32F030
  c include: .\Lib\inc;.\APP;.\Sys;.\CMSIS;.\BSP;./HAL;./Driver;./Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ./: startup_stm32f030.s
  group App
    ./App/: main.c stm32f0xx_it.c
  group Lib
    ./Lib/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group BSP
    ./BSP/: bsp.c
  group HAL
    ./HAL/: hal_uart.c hal_io.c hal_systick.c hal_spi.c
  group Sys
    ./Sys/: system_stm32f0xx.c
  group Driver
    ./Driver/: led.c serial.c hx711.c nrf24l01.c
  group Common
    ./Common/: common.c
